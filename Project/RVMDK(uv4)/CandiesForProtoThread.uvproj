# Keil uVision project CandiesForProtoThread.uvproj, settings and files
target CandiesForProtoThread (ARM-ADS)
  device: STM32F105V8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: CandiesForProtoThread +hex
  c flags: Optim=1
  c include: ..\..\Boot;..\..\FWlib\inc;..\..\User;..\..\PT;..\..\FWlib\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group BOOT
    ../../Boot/: cortexm3_macro.s stm32f10x_vector.s
  group FWLIB
    ../../FWlib/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_systick.c stm32f10x_usart.c
  group USER
    ../../User/: main.c stm32f10x_it.c
  group PT
    ../../PT/: pt_thread.c timer.c
